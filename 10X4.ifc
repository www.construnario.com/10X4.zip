Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\10X4.ifc
Time: 2017-02-03T16:29:38
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO ACRISTALAMIENTO, 10X4
In: Planta Baja
Description: TIRA 3 CALZOS; Material: Color_01
PROPIEDADES TÉRMICAS - TEMPERATURA DE REBLANDECIMIENTO: 123 º C
PROPIEDADES GENERALES - DENSIDAD: 952 Kg/m3 (ISO 1872); TEMPERATURA MÁXIMA DE ALMACENAMIENTO: 60º C; RESSITENCIA QUÍMICA: BUENO; RADIACIÓN ULTRAVIOLETA: BUENO; COLOR STANDARD: AZUL; CARGA MÁXIMA POR PIEZA: 500 Kg; COMPOSICIÓN: POLIETILENO A.D.; PESO POR UNIDAD: 3,2 g
Pset_ManufacturerTypeInformation - ArticleNumber: 0080004; ModelReference: 10X4; ModelLabel: TIRA 3 CALZOS ACRISTALAMIENTO; Manufacturer: JOMBAR; ProductionYear: 2017
PROPIEDADES MECÁNICAS - MÓDULO ELÁSTICO EN FLEXIÓN: 1050 MPa (ISO 178); RESISTENCIA AL IMPACTO CHARPY: 5 KJ/m2 (ISO 179); DUREZA SHORE D: 96+-1 ESCALA A (ISO 868) (DIN EN ISO 14439); TENSIÓN LÍMITE ELÁSTICO: 27 MPa (BP13B/1); ELONGACIÓN A ROTURA: >100 % (BP13B/1)
